options:
  parameters:
    generate_options: qt_gui
    id: GFSK2_RX_BLUE
    output_language: python
    title: GFSK2_RX_BLUE
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: 1000000/52
  states: {state: disabled}
- name: pam2
  id: variable
  parameters:
    value: '[-1, 1]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '47'
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.5'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.5'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.5'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0_0_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.5'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/robot/Radio/record.iq
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/robot/下载/RX_BLUE (2)
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"RM_ELE"'
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate*2
    type: complex
  states: {state: disabled}
- name: blocks_uchar_to_float_0_2_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_2_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: digital_correlate_access_code_xx_ts_0_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '0001011011101000110100110111011100010101000111000111000100101101'
    tagname: RM_ELE
    threshold: '20'
    type: byte
  states: {state: disabled}
- name: digital_gfsk_demod_0_0_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: int(samp_rate/symb_rate)
    sensitivity: '2.5809'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      from scipy import signal
      import time

      class rm_gfsk_receiver(gr.basic_block):
          """
          RoboMaster 2-GFSK 终极高精度解调器 (加入极性互相关，免疫振幅剧变)
          带有秒级性能监控 (Windows 友好型)
          作为最后一个节点 (Sink Block) 运行
          """
          
          def __init__(self, threshold=2400.0, sps=52, packet_bytes=27):
              gr.basic_block.__init__(
                  self,
                  name="RM GFSK Receiver Sink",
                  in_sig=[np.float32],
                  out_sig=[np.uint8]
              )
              self.threshold = threshold
              self.sps = sps
              self.packet_bytes = packet_bytes
              self.packet_bits = packet_bytes * 8
              self.payload_samples = self.packet_bits * self.sps

              access_code_hex = 0x2F6F4C74B914492E
              bits = format(access_code_hex, '064b')
              symbols = np.array([1.0 if b == '1' else -1.0 for b in bits], dtype=np.float32)
              self.kernel = np.repeat(symbols, self.sps)
              self.kernel_len = len(self.kernel) 

              self.buf = np.array([], dtype=np.float32)
              self.state = "SEARCH"
              
              self.rx_count = 0              # 历史总计完美包数
              self.last_print_time = time.time()  # 上次打印的时间戳
              self.success_this_sec = 0      # 这一秒内的成功次数
              self.bad_header_this_sec = 0   # 这一秒内的坏头次数
              self.bad_packet_print_counter = 0 #坏头打印控制
              
              self.max_buf_size = self.payload_samples * 5 

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]

              if len(in0) == 0:
                  return 0

              self.buf = np.concatenate((self.buf, in0))
              self.consume(0, len(in0))
              produced = 0

              if len(self.buf) > self.max_buf_size:
                  self.buf = self.buf[-self.max_buf_size:]

              while True:
                  if self.state == "SEARCH":
                      if len(self.buf) < self.kernel_len*5:
                          break
                      
                      # dc_trend = signal.lfilter([1 - 0.95], [1, -0.95], self.buf)
                      centered_buf = self.buf - np.mean(self.buf)
                      sign_buf = np.sign(centered_buf)
                      sign_buf[sign_buf == 0] = 1.0
                      
                      corr = signal.correlate(sign_buf, self.kernel, mode='valid', method='fft')
                      peaks, _ = signal.find_peaks(corr, height=self.threshold, distance=self.sps*8)

                      if len(peaks) > 0:
                          peak_idx = peaks[0]
                          self.state = "EXTRACT"
                          self.buf = self.buf[peak_idx:]
                      else:
                          self.buf = self.buf[-(self.kernel_len - 1):]
                          break

                  elif self.state == "EXTRACT":
                      if len(self.buf) >= self.payload_samples:

                          packet_wave = self.buf[:self.payload_samples]
                          self.buf = self.buf[self.payload_samples:]

                          #动态匹配波形中心部分，减少振幅剧变的影响
                          preamble_wave = packet_wave[:64 * self.sps]
                          high_level = np.percentile(preamble_wave, 90)
                          low_level = np.percentile(preamble_wave, 10)

                          symbols_matrix = packet_wave.reshape(-1, self.sps)
                          start_idx = self.sps // 2 - 2
                          end_idx = self.sps  // 2 + 2
                          symbol_voltages = np.mean(symbols_matrix[:, start_idx:end_idx], axis=1)

                          bits = np.zeros(len(symbol_voltages), dtype=np.uint8)
                          # alpha = 0.1
                          
                          for i, v in enumerate(symbol_voltages):
                              threshold = (high_level + low_level) / 2.0
                              if v > threshold:
                                  bits[i] = 1
                                  # high_level = (1 - alpha) * high_level + alpha * v
                              else:
                                  bits[i] = 0
                                  # low_level = (1 - alpha) * low_level + alpha * v

                          byte_array = np.packbits(bits)

                          
                          # 成功和失败的计数逻辑
                          if byte_array[0] == 0x2F and byte_array[1] == 0x6F:
                              self.rx_count += 1
                              self.success_this_sec += 1 # 成功计数器 +1
                              #print(f"[{time.strftime('%H:%M:%S')}] 📦 完美包 #{self.rx_count} | {hex_str}")

                              # 核心修改：切片获取后 15 个字节 (假设总长 27，12:27 就是后 15 个)
                              payload = byte_array[-15:] 
                              payload_len = len(payload) # 这里是 15

                              # 把这纯净的 15 个字节输出给 downstream 的 ZMQ
                              out[produced : produced + payload_len] = payload
                              tag_index = self.nitems_written(0) + produced
                              self.add_item_tag(0, tag_index, pmt.intern("packet_len"), pmt.from_long(payload_len))
                              produced += payload_len
                              
                          else:
                              self.bad_header_this_sec += 1 # 误码计数器 +1
                              self.bad_packet_print_counter += 1 
                              
                              # 【修改点】满 10 个坏包时，把包的内容转成 16 进制打印出来
                              if self.bad_packet_print_counter >= 10:
                                  # 将 byte_array 转换为例如 "2F 6E 4C ..." 的格式
                                  hex_data = ' '.join([f'{b:02X}' for b in byte_array])
                                  print(f"[{time.strftime('%H:%M:%S')}] ⚠️ 第 10 个坏包内容: {hex_data}")
                                  self.bad_packet_print_counter = 0

                          self.state = "SEARCH"
                      else:
                          break
              
              current_time = time.time()
              if current_time - self.last_print_time >= 1.0:
                  print(f"[{time.strftime('%H:%M:%S')}] 性能监控 | 成功: {self.success_this_sec} 包/秒 | 丢弃(假峰/坏头): {self.bad_header_this_sec} 次/秒 | 总接收: {self.rx_count}")
                  
                  self.success_this_sec = 0
                  self.bad_header_this_sec = 0
                  self.last_print_time = current_time

              return produced
    packet_bytes: '27'
    sps: '52'
    threshold: '1500'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      from scipy import signal

      class rm_gfsk_score_monitor(gr.sync_block):
          """
          RoboMaster 2-GFSK 相关性打分监视器 (输出连续的匹配波形)
          """
          def __init__(self, sps=52):
              gr.sync_block.__init__(
                  self,
                  name="RM GFSK Score Monitor",
                  in_sig=[np.float32],
                  out_sig=[np.float32] # 输出连续的 Float32 波形
              )
              self.sps = sps
              
              # 生成 Access Code 理想波形
              access_code_hex = 0x2F6F4C74B914492E
              bits = format(access_code_hex, '064b')
              symbols = np.array([1.0 if b == '1' else -1.0 for b in bits], dtype=np.float32)
              self.kernel = np.repeat(symbols, self.sps)
              self.kernel_len = len(self.kernel)
              
              # 让底层的 C++ 帮我们完美管理滑动窗口
              self.set_history(self.kernel_len)

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              # --- 增加：和接收端一模一样的预处理逻辑 ---
              # 1. 动态去直流
              centered_in0 = in0 - np.mean(in0)
              
              # 2. 极性二值化 (强制压平为 +1 和 -1)
              sign_in0 = np.sign(centered_in0)
              sign_in0[sign_in0 == 0] = 1.0
              
              # 3. 使用二值化后的波形算得分
              corr = signal.correlate(sign_in0, self.kernel, mode='valid', method='fft')
              
              out[:] = corr
              return len(out)
    sps: sps
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '2'
    samp_rate: samp_rate*2
    taps: firdes.low_pass(1.0,samp_rate*2,480000,40000)
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '400000'
    decim: '2'
    samp_rate: samp_rate*2
    taps: firdes.low_pass(1.0,samp_rate*2,480000,40000)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '400000'
    decim: '4'
    samp_rate: samp_rate*4
    taps: firdes.low_pass(1.0,samp_rate*4,125000,40000)
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '100000'
    decim: '2'
    samp_rate: samp_rate*2
    taps: firdes.low_pass(1.0,samp_rate*2,420000,40000)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-600000'
    decim: '2'
    samp_rate: samp_rate*2
    taps: firdes.low_pass(1.0,samp_rate*2,270000,40000)
    type: ccc
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: '2000000'
    bbdc: 'True'
    buffer_size: '65536'
    filter_source: '''Auto'''
    frequency: '434520000'
    gain2: '''slow_attack'''
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'False'
    rx2_en: 'True'
    samplerate: samp_rate*2
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '2000000'
    bbdc: 'True'
    buffer_size: '65536'
    filter_source: '''Auto'''
    frequency: '434520000'
    gain1: '''slow_attack'''
    manual_gain1: '0'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate*2
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '250000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '50000'
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '480000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '40000'
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '123000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '40000'
    win: window.WIN_BLACKMAN
  states: {state: disabled}
- name: low_pass_filter_0_1_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '410000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '40000'
    win: window.WIN_BLACKMAN
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"final_noise"'
    size: '1024'
    srate: symb_rate/8
    type: float
    ymax: '256'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"final_noise"'
    size: '1024'
    srate: symb_rate/8
    type: float
    ymax: '256'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"final_number"'
    size: '1024'
    srate: symb_rate/8
    type: float
    ymax: '256'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"final_number"'
    size: '1024'
    srate: symb_rate/8
    type: float
    ymax: '256'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"score"'
    size: '1024'
    srate: symb_rate
    type: float
    ymax: '256'
    ymin: '0'
  states: {state: disabled}
- name: robomaster_gfsk_receiver_0
  id: robomaster_gfsk_receiver
  parameters:
    packet_bytes: '27'
    sps: '47'
    threshold: '1100'
  states: {}
- name: robomaster_gfsk_receiver_noise_0
  id: robomaster_gfsk_receiver_noise
  parameters:
    packet_bytes: '27'
    sps: '47'
    threshold: '900'
  states: {}
- name: robomaster_gfsk_receiver_noise_0_0
  id: robomaster_gfsk_receiver_noise
  parameters:
    packet_bytes: '27'
    sps: '52'
    threshold: '1000'
  states: {state: disabled}
- name: robomaster_gfsk_receiver_noise_0_1
  id: robomaster_gfsk_receiver_noise
  parameters:
    packet_bytes: '27'
    sps: '47'
    threshold: '900'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:6666
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_pub_sink_0_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:6668
    timeout: '100'
    type: byte
  states: {state: disabled}
- name: zeromq_pub_sink_0_0_1
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:6667
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_1_1_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', low_pass_filter_0_1, '0']
- [analog_quadrature_demod_cf_0_0_0, '0', low_pass_filter_0_1_0, '0']
- [analog_quadrature_demod_cf_0_0_1, '0', low_pass_filter_0_1_1, '0']
- [blocks_file_source_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_throttle2_0_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [blocks_throttle2_0_0, '0', freq_xlating_fir_filter_xxx_0_0_0_1, '0']
- [blocks_throttle2_0_0, '0', freq_xlating_fir_filter_xxx_0_0_0_2, '0']
- [blocks_uchar_to_float_0_2_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_uchar_to_float_0_2_0_1, '0', qtgui_time_sink_x_0_1_0_1, '0']
- [blocks_unpacked_to_packed_xx_0_0, '0', blocks_tag_debug_0_0, '0']
- [blocks_unpacked_to_packed_xx_0_0, '0', blocks_uchar_to_float_0_2_0, '0']
- [digital_correlate_access_code_xx_ts_0_0_0, '0', blocks_unpacked_to_packed_xx_0_0, '0']
- [digital_gfsk_demod_0_0_0, '0', blocks_uchar_to_float_0_2_0_1, '0']
- [digital_gfsk_demod_0_0_0, '0', digital_correlate_access_code_xx_ts_0_0_0, '0']
- [epy_block_0, '0', zeromq_pub_sink_0, '0']
- [epy_block_1, '0', qtgui_time_sink_x_0_1_1_1, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', digital_gfsk_demod_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', analog_quadrature_demod_cf_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_1, '0', analog_quadrature_demod_cf_0_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_2, '0', analog_quadrature_demod_cf_0, '0']
- [iio_fmcomms2_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [iio_fmcomms2_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_1, '0']
- [iio_fmcomms2_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_2, '0']
- [iio_pluto_source_0, '0', blocks_file_sink_0, '0']
- [iio_pluto_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [iio_pluto_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [iio_pluto_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [iio_pluto_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_1, '0']
- [iio_pluto_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_2, '0']
- [low_pass_filter_0, '0', epy_block_0, '0']
- [low_pass_filter_0, '0', epy_block_1, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_1_1, '0']
- [low_pass_filter_0, '0', robomaster_gfsk_receiver_0, '0']
- [low_pass_filter_0_1, '0', robomaster_gfsk_receiver_noise_0, '0']
- [low_pass_filter_0_1_0, '0', robomaster_gfsk_receiver_noise_0_0, '0']
- [low_pass_filter_0_1_1, '0', robomaster_gfsk_receiver_noise_0_1, '0']
- [robomaster_gfsk_receiver_0, '0', zeromq_pub_sink_0, '0']
- [robomaster_gfsk_receiver_noise_0, '0', zeromq_pub_sink_0_0, '0']
- [robomaster_gfsk_receiver_noise_0_0, '0', zeromq_pub_sink_0_0_0, '0']
- [robomaster_gfsk_receiver_noise_0_1, '0', zeromq_pub_sink_0_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
